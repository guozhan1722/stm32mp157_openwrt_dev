# Keil uVision project OpenAMP_raw.uvprojx, settings and files
target Engineering (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.0.0.1-dev5
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: OpenAMP_raw
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32MP157Cxx,CORE_CM4,METAL_INTERNAL,METAL_MAX_DEVICE_REGIONS=2,VIRTIO_SLAVE_ONLY,__LOG_TRACE_IO_,NO_ATOMIC_64_SUPPORT
  c include: ../Inc;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32MP15xx_EVAL;../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp15xx_m4.sct
  group Application/MDK-ARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: lock_resource.c main.c stm32mp1xx_it.c stm32mp1xx_hal_msp.c openamp_log.c mbox_ipcc.c openamp.c rsc_table.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32MP15xx_EVAL
    ../../../../../../Drivers/BSP/STM32MP15xx_EVAL/: stm32mp15xx_eval.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Middlewares/OpenAMP/libmetal
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
  group Middlewares/OpenAMP/libmetal/generic
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: generic_device.c generic_init.c generic_io.c generic_shmem.c time.c condition.c irq.c
  group Middlewares/OpenAMP/libmetal/generic/cortexm
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
  group Middlewares/OpenAMP/open-amp/remoteproc
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
  group Middlewares/OpenAMP/open-amp/rpmsg
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
  group Middlewares/OpenAMP/virtual_driver
    ../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver/: virt_uart.c
target Production (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.0.0.1-dev5
  cpu: as above
  output: OpenAMP_raw
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: as above
  c include: /RTE/_Production;../Inc;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32MP15xx_EVAL;../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver;../Common/Inc/openamp
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp15xx_m4.sct
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
